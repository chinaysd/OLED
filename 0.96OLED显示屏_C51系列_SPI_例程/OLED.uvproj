# Keil uVision project OLED.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC92F7322 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(24000000)
  output: OLED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\SRC
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./SRC/: oled.c
